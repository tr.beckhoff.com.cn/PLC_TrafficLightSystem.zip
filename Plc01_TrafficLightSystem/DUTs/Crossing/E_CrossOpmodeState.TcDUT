//{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_CrossOpmodeState :
(
	eCrossOpmode_Commissioning 	:= 0,
	eCrossOpmode_Automatic 		:= 1
);
END_TYPE
