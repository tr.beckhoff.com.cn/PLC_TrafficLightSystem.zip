//{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_CrossAutomaticState :
(
	eCrossAutomatic_StandBy := 0,
	eCrossAutomatic_Active 	:= 1	
);
END_TYPE
