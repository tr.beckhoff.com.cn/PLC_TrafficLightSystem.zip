//{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_STLOpmodeState :
(
	eSTLOpmode_Commissioning	:= 0,
	eSTLOpmode_Automatic 		:= 1
);
END_TYPE
