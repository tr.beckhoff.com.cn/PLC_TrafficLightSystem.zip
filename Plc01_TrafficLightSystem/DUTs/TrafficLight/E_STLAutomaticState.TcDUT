//{attribute 'qualified_only'}
{attribute 'strict'}
TYPE E_STLAutomaticState :
(
	eSTLAutomatic_StandBy 	:= 0,	
	eSTLAutomatic_Active 	:= 1
);
END_TYPE
